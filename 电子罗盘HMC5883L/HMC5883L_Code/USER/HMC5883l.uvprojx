# Keil uVision project HMC5883l.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F101RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HMC5883l +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DELAY_5883L;..\HARDWARE\IIC_5883L;..\HARDWARE\SIGNAL_5883L;..\USER;..\STM32F10X;..\STM32F10X\USB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: main.c
  group SYSYTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARD
    ../HARDWARE/DELAY_5883L/: delay_5883.c
    ../HARDWARE/IIC_5883L/: IIC_5883.c
    ../HARDWARE/SIGNAL_5883L/: signal_5883.c
